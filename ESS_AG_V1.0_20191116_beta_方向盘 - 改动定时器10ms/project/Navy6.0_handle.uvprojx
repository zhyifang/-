# Keil uVision project Navy6.0_handle.uvprojx, settings and files
target nrf51422_xxac_s110 (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.24.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac_s110 +hex
  c flags: Optim=2 OneElfS=1
  c define: NRF51  BLE_STACK_SUPPORT_REQD BOARD_PCA10028 S110 NRF51 SOFTDEVICE_PRESENT USE_SD_HW_RESOURCES
  c misc: --c99
  c include: ..\..\EP_Navy6.0_handle_0321;..\Src\RTT;..\Src
  asm define: BLE_STACK_SUPPORT_REQD BOARD_PCA10028 S110 NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x28600
  memory RVCT9: RAM 0x20002600 size 0x2100
  group Application
    ../Src/: main.c ep_button.c ep_buzzer.c ep_comm.c ep_crypt_device.c ep_gzll.c ep_hall.c ep_lcd_6kw.c ep_motor.c ep_PowerSwitch.c ep_pstorage.c ep_sys.c ep_throttle.c ep_timeSlot.c ep_wdt.c nrf_gzp.c ep_ble_access.c ble_nus.c ep_ble_admin.c ep_ble_battery.c ep_ble_navigation.c ep_ble_init.c ep_ble_Device_Info.c ep_ble_steer.c ep_ble_motor.c ep_ble_comm.c ep_version.c ep_tick.c ep_led.c myiic.c as5600.c
target flash_softdevice (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.24.1
  cpu: as above
  output: s110_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD
  c misc: --c99
  asm define: BLE_STACK_SUPPORT_REQD
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: CMSIS:CORE 4.3.0, Device:Startup 8.11.1, nRF_BLE:BLE_Modules:ble_advdata 3.0.1, nRF_BLE:BLE_Modules:ble_advertising 3.0.1, nRF_BLE:BLE_Modules:ble_common 3.0.1, nRF_BLE:BLE_Modules:ble_conn_params 3.0.1, nRF_BLE:BLE_Modules:ble_service_common 3.0.1, nRF_Drivers:nrf_delay 3.0.1, nRF_Drivers:nrf_drv_clock 3.0.1, nRF_Drivers:nrf_drv_common 3.0.1, nRF_Drivers:nrf_drv_gpiote 3.0.1, nRF_Drivers:nrf_ecb 3.0.1, nRF_Drivers:nrf_error 3.0.1, nRF_Drivers:nrf_gpio 3.0.1, nRF_Drivers:nrf_gpiote 3.0.1, nRF_Drivers:nrf_nvmc 3.0.1, nRF_Drivers:nrf_soc 3.0.1, nRF_Drivers:pstorage 3.0.1, nRF_Libraries:app_button 3.0.1, nRF_Libraries:app_error 3.0.1, nRF_Libraries:app_timer 3.0.1, nRF_Libraries:app_trace 3.0.1, nRF_Libraries:app_util 3.0.1, nRF_Libraries:nrf_assert 3.0.1, nRF_Properitary_RF:gzll 1.2.1, nRF_SoftDevice:Internal:sd_common 1.1.4, nRF_SoftDevice:Internal:softdevice_present 1.1.4, nRF_SoftDevice:s110 8.0.2, nRF_SoftDevice:s110_hex 8.0.2, nRF_SoftDevice:softdevice_hex 1.1.4
