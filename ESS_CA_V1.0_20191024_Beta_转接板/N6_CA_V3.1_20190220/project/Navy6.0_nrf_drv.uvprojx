# Keil uVision project Navy6.0_nrf_drv.uvprojx, settings and files
target nrf51422_xxac_s110 (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.24.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac_s110 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: BLE_STACK_SUPPORT_REQD BOARD_PCA10028 S110 NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0 DEBUG_NRF
  c misc: --c99
  c include: ..\..\nrf51822_gzll_ble;..\Include;..\Source;..\arm5
  asm define: BLE_STACK_SUPPORT_REQD BOARD_PCA10028 S110 NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x28000
  memory RVCT9: RAM 0x20002000 size 0x6000
  group User
    ../User/: main.c ep_tick.c ep_comm.c ep_motor.c ep_pstorage.c ep_gzll.c ep_ble_stack.c nrf_gzp_host_nrf51.c ep_crypt_host.c nrf_gzp.c ep_rs485.c ep_version.c ep_spi_slave.c ep_wdt.c
  group Documentation
    ../../../: Abstract.txt license.txt
software components: CMSIS:CORE 4.3.0, Device:Startup 8.0.3, nRF_Drivers:app_uart 3.0.1, nRF_Drivers:nrf_delay 3.0.1, nRF_Drivers:nrf_drv_common 3.0.1, nRF_Drivers:nrf_ecb 3.0.1, nRF_Drivers:nrf_error 3.0.1, nRF_Drivers:nrf_nvmc 3.0.1, nRF_Drivers:nrf_soc 3.0.1, nRF_Drivers:pstorage 3.0.1, nRF_Libraries:app_error 3.0.1, nRF_Libraries:app_util 3.0.1, nRF_Libraries:nordic_common 3.0.1, nRF_Libraries:nrf_assert 3.0.1, nRF_Properitary_RF:gzll 1.2.1, nRF_SoftDevice:Internal:sd_common 1.1.4, nRF_SoftDevice:Internal:softdevice_present 1.1.4, nRF_SoftDevice:s110 8.0.2, nRF_SoftDevice:s110_hex 8.0.2, nRF_SoftDevice:softdevice_hex 1.1.4
